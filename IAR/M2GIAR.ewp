# IAR project M2GIAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __USE_LPCOPEN; __USE_WATCHDOG; USE_SYSVIEW___; M2G_PROTOB; CHIP_LPC43XX; CORE_M4; NDEBUG; c__onfigUSE_SEGGER_SYSTEM_VIEWER_HOOKS=1; OS_FLAGS_TEST
  ICCARM.CCDiagSuppress: Pa089, Pe111, Pe188
  ICCARM.CCIncludePath2: ..\mculib\mcu_usb_vcom; ..\mculib\mcu_inc; ..\mculib\mcu_config; ..\mculib\mcu_inc\usbd; ..\middleware\middleware\mid_inc; ..\middleware\middleware\SEGGER\SEGGER; ..\middleware\middleware\SEGGER\OS; ..\middleware\middleware\SEGGER\Config; ..\middleware\AuteqOS\os_inc; ..\middleware\AuteqOS\os_extras\ARM_CM4F_IAR; ..\middleware\AuteqOS\os_extras\CMSIS\include; ..\App\common\app_common; ..\App\common\app_inc; ..\App\broker\inc; ..\App\broker\test; ..\App\diagnostic\inc; ..\App\isobus\inc; ..\App\sensor\inc; ..\devices\dev_common; ..\devices\dev_inc; ..\devices\mcu_inc; ..\inc; ..\App\buzzer\inc; ..\App\test\inc; ..\App\filesys\inc; ..\App\gps\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __USE_LPCOPEN; USE_SYSVIEW; M2G_PROTOB; CHIP_LPC43XX; CORE_M4; NDEBUG
  AARM.AUserIncludes: ..\mculib\mcu_usb_vcom; ..\mculib\mcu_inc; ..\mculib\mcu_config; ..\mculib\mcu_inc\usbd; ..\middleware\middleware\mid_inc; ..\middleware\middleware\SEGGER\SEGGER; ..\middleware\middleware\SEGGER\OS; ..\middleware\middleware\SEGGER\Config; ..\middleware\AuteqOS\os_inc; ..\middleware\AuteqOS\os_extras\ARM_CM4F_IAR; ..\middleware\AuteqOS\os_extras\CMSIS\include; ..\App\common\app_common; ..\App\common\app_inc; ..\App\broker\inc; ..\App\broker\test; ..\App\diagnostic\inc; ..\devices\dev_common; ..\devices\dev_inc; ..\devices\mcu_inc; common_IAR; ..\inc
  OBJCOPY.OOCOutputFile: M2GIAR.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: linker\lpc4357_m4_modified_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __USE_LPCOPEN; __USE_WATCHDOG; USE_SYSVIEW; M2G_PROTOB; CHIP_LPC43XX; CORE_M4; NDEBUG; configUSE_SEGGER_SYSTEM_VIEWER_HOOKS=1; OS_FLAGS_TEST
  ICCARM.CCIncludePath2: ..\mculib\mcu_usb_vcom; ..\mculib\mcu_inc; ..\mculib\mcu_config; ..\mculib\mcu_inc\usbd; ..\middleware\middleware\mid_inc; ..\middleware\middleware\SEGGER\SEGGER; ..\middleware\middleware\SEGGER\OS; ..\middleware\middleware\SEGGER\Config; ..\middleware\AuteqOS\os_inc; ..\middleware\AuteqOS\os_extras\ARM_CM4F_IAR; ..\middleware\AuteqOS\os_extras\CMSIS\include; ..\App\common\app_common; ..\App\common\app_inc; ..\App\broker\inc; ..\App\broker\test; ..\App\diagnostic\inc; ..\App\isobus\inc; ..\App\sensor\inc; ..\devices\dev_common; ..\devices\dev_inc; ..\devices\mcu_inc; ..\inc; ..\App\buzzer\inc; ..\App\test\inc
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\mculib\mcu_usb_vcom; ..\mculib\mcu_inc; ..\mculib\mcu_config; ..\mculib\mcu_inc\usbd; ..\middleware\middleware\mid_inc; ..\middleware\middleware\SEGGER\SEGGER; ..\middleware\middleware\SEGGER\OS; ..\middleware\middleware\SEGGER\Config; ..\middleware\AuteqOS\os_inc; ..\middleware\AuteqOS\os_extras\ARM_CM4F_IAR; ..\middleware\AuteqOS\os_extras\CMSIS\include; ..\App\common\app_common; ..\App\common\app_inc; ..\App\broker\inc; ..\App\broker\test; ..\App\diagnostic\inc; ..\devices\dev_common; ..\devices\dev_inc; ..\devices\mcu_inc; ..\inc
  OBJCOPY.OOCOutputFile: M2GIAR.hex
  group App/broker/config
    ../App/broker/config/: Readme.md
  group App/broker/inc
    ../App/broker/inc/: broker_includeall.h interface_broker.h
  group App/broker/src
    ../App/broker/src/: broker_core.c broker_core.h broker_list.c broker_list.h broker_subscriptor.c broker_subscriptor.h broker_threadControl.h
  group App/broker/test
    ../App/broker/test/: test_broker.c test_broker.h unity_test_broker_runner.c
  group App/buzzer/config
    ../App/buzzer/config/: buzzer_config.h
  group App/buzzer/inc
    ../App/buzzer/inc/: interface_buzzer.h
  group App/buzzer/src
    ../App/buzzer/src/: buzzer_core.c buzzer_core.h buzzer_ThreadControl.h
  group App/common
    ../App/common/: Readme.md
  group App/common/app_common
    ../App/common/app_common/: common_app.h
  group App/common/app_inc
    ../App/common/app_inc/: debug_tool.h ring_buffer.h
  group App/common/app_src
    ../App/common/app_src/: debug_tool.c ring_buffer.c
  group App/diagnostic/config
    ../App/diagnostic/config/: diagnostic_config.h Readme.md
  group App/diagnostic/inc
    ../App/diagnostic/inc/: interface_diagnostic.h
  group App/diagnostic/src
    ../App/diagnostic/src/: diagnostic_core.c diagnostic_core.h diagnostic_logger.c diagnostic_logger.h diagnostic_ThreadControl.h
  group App/diagnostic/test
    ../App/diagnostic/test/: unity_test_diagnostic_runner.c
  group App/filesys/config
    ../App/filesys/config/: filesys_config.h
  group App/filesys/inc
    ../App/filesys/inc/: interface_filesys.h
  group App/filesys/src
    ../App/filesys/src/: filesys_core.c filesys_core.h filesys_ThreadControl.h
  group App/gps/config
    ../App/gps/config/: gps_config.h
  group App/gps/inc
    ../App/gps/inc/: interface_gps.h
  group App/gps/src
    ../App/gps/src/: gps_core.c gps_core.h gps_ThreadControl.h
  group App/isobus/config
    ../App/isobus/config/: isobus_config.h
  group App/isobus/inc
    ../App/isobus/inc/: interface_isobus.h
  group App/isobus/src
    ../App/isobus/src/: iso11783.c iso11783.h isobus_core.c isobus_core.h isobus_ThreadControl.h object_pool.c
  group App/sensor/config
    ../App/sensor/config/: sensor_config.h
  group App/sensor/inc
    ../App/sensor/inc/: interface_sensor.h
  group App/sensor/src
    ../App/sensor/src/: sensor_aquireg.c sensor_aquireg.h sensor_core.c sensor_core.h sensor_management.c sensor_management.h sensor_ThreadControl.h
  group App/test/config
    ../App/test/config/: test_config.h
  group App/test/inc
    ../App/test/inc/: interface_test.h
  group App/test/src
    ../App/test/src/: test_core.c test_core.h test_ThreadControl.h
  group common_IAR
    common_IAR/: iar_startup_lpc18xx43xx.s
  group devices
    ../devices/: Readme.md
  group devices/dev_common
    ../devices/dev_common/: CBACOMM_config.h CBT09427_config.h CHIPPROG_config.h EXTBUZZER_config.h FLASHER_config.h KEYBACKLIGHT_config.h LCDBACKLIGHT_config.h M2GGPSCOMM_config.h M2GISOCOMM_config.h M2GSENSORCOMM_config.h MLX75305_config.h termdev_config.h WATCHDOG_config.h
  group devices/dev_inc
    ../devices/dev_inc/: CBACOMM.h CBT09427.h CHIPPROG.h deviceerror.h devicelib.h EXTBUZZER.h FLASHER.h KEYBACKLIGHT.h LCDBACKLIGHT.h M2GGPSCOMM.h M2GISOCOMM.h M2GSENSORCOMM.h MLX75305.h termdev.h WATCHDOG.h
  group devices/dev_src
    ../devices/dev_src/: CBACOMM.c CBT09427.c CHIPPROG.c devicelib.c EXTBUZZER.c FLASHER.c KEYBACKLIGHT.c LCDBACKLIGHT.c M2GGPSCOMM.c M2GISOCOMM.c M2GSENSORCOMM.c MLX75305.c termdev.c WATCHDOG.c
  group devices/dev_test
    ../devices/dev_test/: unity_test_CBACOMM_runner.c unity_test_FLASH_runner.c unity_test_KEYBACKLIGHT_runner.c unity_test_LCDBACKLIGHT_runner.c unity_test_MLX75305_runner.c unity_test_TERMDEV_runner.c unity_test_WATCHDOG_runner.c
  group devices/mcu_inc
    ../devices/mcu_inc/: adc.h can.h gpio.h iap.h lcd.h mcu.h mcuerror.h mculib.h pwm.h spifi.h uart.h usbcdc.h wdt.h
  group inc
    ../inc/: M2G_app.h
  group linker
    linker/: LPC1857_No_Bootloader.icf lpc18xx_43xx_debug.mac lpc18xx_43xx_debug_iram.mac lpc18xx_43xx_iflash_heap.icf lpc18xx_43xx_ldscript_iflash.icf lpc18xx_43xx_ldscript_iram.icf lpc18xx_43xx_ldscript_spifi.icf lpc18xx_43xx_spifi_heap.icf lpc18xx_43xx_spifi_ldscript.icf lpc4357_m4 (2).icf lpc4357_m4.icf lpc4357_m4_modified_app.icf
  group mculib
    ../mculib/: Readme.md
  group mculib/mcu_config
    ../mculib/mcu_config/: board.c board.h
  group mculib/mcu_inc
    ../mculib/mcu_inc/: adc_18xx_43xx.h aes_18xx_43xx.h atimer_18xx_43xx.h ccan_18xx_43xx.h cguccu_18xx_43xx.h chip.h chip_clocks.h chip_lpc18xx.h chip_lpc43xx.h clock_18xx_43xx.h cmsis.h cmsis_43xx.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h creg_18xx_43xx.h dac_18xx_43xx.h eeprom_18xx_43xx.h emc_18xx_43xx.h enet_18xx_43xx.h error.h evrt_18xx_43xx.h fmc_18xx_43xx.h fpu_init.h gima_18xx_43xx.h gpdma_18xx_43xx.h gpio_18xx_43xx.h gpiogroup_18xx_43xx.h hsadc_18xx_43xx.h i2c_18xx_43xx.h i2c_common_18xx_43xx.h i2cm_18xx_43xx.h i2s_18xx_43xx.h iap_18xx_43xx.h lcd_18xx_43xx.h lpc_types.h mcpwm_18xx_43xx.h mcpwm_43xx.h otp_18xx_43xx.h pinint_18xx_43xx.h pmc_18xx_43xx.h qei_18xx_43xx.h rgu_18xx_43xx.h ritimer_18xx_43xx.h romapi_18xx_43xx.h rtc_18xx_43xx.h sct_18xx_43xx.h sct_pwm_18xx_43xx.h scu_18xx_43xx.h sdif_18xx_43xx.h sdio_18xx_43xx.h sdmmc.h sdmmc_18xx_43xx.h sgpio_18xx_43xx.h spi_18xx_43xx.h spifilib_api.h spifilib_dev.h ssp_18xx_43xx.h stopwatch.h sys_config.h timer_18xx_43xx.h uart_18xx_43xx.h usbhs_18xx_43xx.h wwdt_18xx_43xx.h
  group mculib/mcu_inc/private
    ../mculib/mcu_inc/private/: spifilib_chiphw.h
  group mculib/mcu_inc/usbd
    ../mculib/mcu_inc/usbd/: usbd.h usbd_adc.h usbd_cdc.h usbd_cdcuser.h usbd_core.h usbd_desc.h usbd_dfu.h usbd_dfuuser.h usbd_hid.h usbd_hiduser.h usbd_hw.h usbd_msc.h usbd_mscuser.h usbd_rom_api.h
  group mculib/mcu_src
    ../mculib/mcu_src/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c fpu_init.c gpdma_18xx_43xx.c gpio_18xx_43xx.c gpiogroup_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c iap_18xx_43xx.c lcd_18xx_43xx.c mcpwm_43xx.c otp_18xx_43xx.c pinint_18xx_43xx.c pmc_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c sdif_18xx_43xx.c sdio_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c spifilib_dev_common.c spifilib_fam_standard_cmd.c ssp_18xx_43xx.c stopwatch_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
  group mculib/mcu_usb_vcom
    ../mculib/mcu_usb_vcom/: app_usbd_cfg.h cdc_desc.c cdc_vcom.c cdc_vcom.h
  group mculib/mcudev_src
    ../mculib/mcudev_src/: adc.c can.c gpio.c iap.c lcd.c mcu.c pwm.c spifi.c uart.c usbcdc.c wdt.c
  group middleware/AuteqOS
    ../middleware/AuteqOS/: Readme.md
  group middleware/AuteqOS/os_extras/ARM_CM4F_IAR
    ../middleware/AuteqOS/os_extras/ARM_CM4F_IAR/: port.c portasm.s portmacro.h
  group middleware/AuteqOS/os_extras/CMSIS/include
    ../middleware/AuteqOS/os_extras/CMSIS/include/: arm_common_tables.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h LPC43xx.h
  group middleware/AuteqOS/os_inc
    ../middleware/AuteqOS/os_inc/: core_cmFunc.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group middleware/AuteqOS/os_src
    ../middleware/AuteqOS/os_src/: auteq_os.c croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group middleware/middleware
    ../middleware/middleware/: Readme.md
  group middleware/middleware/emWin/inc
    ../middleware/middleware/emWin/inc/: BUTTON.h CALENDAR.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13781.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h GUITDRV_ADS7846.h HEADER.h ICONVIEW.h IMAGE.h IMAGE_Private.h KNOB.h LCD.h LCD_ConfDefaults.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group middleware/middleware/emWin/libs/IAR
    ../middleware/middleware/emWin/libs/IAR/: emWin_M4F.a emWin_M4F_d5.a
  group middleware/middleware/mid_inc
    ../middleware/middleware/mid_inc/: auteq_os.h
  group middleware/middleware/SEGGER/Config
    ../middleware/middleware/SEGGER/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_FreeRTOS.c
  group middleware/middleware/SEGGER/OS
    ../middleware/middleware/SEGGER/OS/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
  group middleware/middleware/SEGGER/SEGGER
    ../middleware/middleware/SEGGER/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group src
    ../src/: M2G_app_main.c M2GMainThread.c wds.c wds.h
